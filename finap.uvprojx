# Keil uVision project finap.uvprojx, settings and files
target tm4c (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: finap
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Src
    ./: main.c game.c game.h OLED.c OLED.h I2C.c I2C.h font.c font.h Pong2player.c Pong2player.h pongcourt.c pongcourt.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
